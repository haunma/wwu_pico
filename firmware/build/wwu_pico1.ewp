# IAR project wwu_pico1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L031F4 ST STM32L031F4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L0; STM32L0xx
  ICCARM.CCIncludePath2: ..\src; ..\Si5351-lib\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: wwu_pico1.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32l031xx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG; STM32L0; STM32L0xx
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/: DADC.cpp DADC.h DGPIO.cpp DGPIO.h DI2C.cpp DI2C.h DPower.cpp DPower.h DRadio.cpp DRadio.h DRTC.cpp DRTC.h interrupts.cpp interrupts.h main.cpp
    ../Si5351-lib/src/: si5351.c
    ../Si5351-lib/inc/: si5351.h
    ./: stm32l031xx.icf
  group CMSIS
    ../src/: startup_stm32l031xx.s stm32l031xx.h stm32l0xx.h
